# Keil uVision project ComputerControl.uvproj, settings and files
target Target 1 (MCS-51)
  device: AT89C52 Microchip
  cpu: IRAM(0-0xFF) IROM(0-0x1FFF) CLOCK(24000000)
  output: ComputerControl +hex
  c flags: Optimize=8 SizeSpeed=1
  c include: .\Code
  group Source Group 1
    ./: STARTUP.A51 main.c
    ./Code/: Disp.c ADC.c Timer.c DAC.c Key.c Filter.c Sort.c
